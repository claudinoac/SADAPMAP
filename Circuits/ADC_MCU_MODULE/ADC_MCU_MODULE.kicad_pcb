# Repository claudinoac/SADAPMAP

File README.md:

# <h1> SADAMAP </h1>
<h2> Sistema de Aquisição de Dados para Análise de Materiais em Altas Pressões </h2>

<h3> Pré Requisitos de Instalação: </h3> 

<h4> Python 3.2+: </h4>
<ul> 
	<li> https://www.python.org/downloads/ </li>
</ul>
<h4>  </h4>
<h4> Bibliotecas Python: </h4>
<ul> 
	<li>  PyQtGraph: http://www.pyqtgraph.org/ </li>
	<li>  Numpy: http://www.numpy.org/ </li>
	<li>  PySerial: https://github.com/pyserial/pyserial </li>
	<li>  PyQt5: https://www.riverbankcomputing.com/software/pyqt/download5
</ul>

## KiCad design Circuits/ADC_MCU_MODULE/ADC_MCU_MODULE.kicad_pcb

Parts:
C1: 22u; C_Radial_D5_L6_P2.5
C2, C3, C4, C5, C6, C7, C8, C9: 100n; C_Rect_L7_W2.5_P5
J1: Arduino_Nano_Header; arduino_nano_header
P1: POWER; bornier2
P2, P3, P4, P5, P6, P7, P8, P9: BNC; bornier2
P10: TEMP_MODULE_OUT; kk100_22-23-2061
P11: V_AMP SEL CH-B; kk100_22-23-2051
P12: V_AMP SEL CH-A; kk100_22-23-2051
P13: V_AMP SEL CH-C; kk100_22-23-2051
R1: 10R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R2, R3, R4, R5, R6, R7, R8, R9: 47k; RC03
U1, U2: ADS1115

Connections:
+5V: C1.1, J1.27 (5V), J1.30 (VIN), P10.2, R1.2, U1.1 (VCC), U2.1 (VCC), U2.5 (ADDR)
ADC1: C2.1, R2.1, U1.7 (A0)
ADC2: C5.1, R5.1, U1.8 (A1)
ADC3: C3.1, R3.1, U1.9 (A2)
ADC4: C4.1, R4.1, U1.10 (A3)
ADC5: C6.1, R6.1, U2.7 (A0)
ADC6: C7.1, R7.1, U2.8 (A1)
ADC7: C8.1, R8.1, U2.9 (A2)
ADC8: C9.1, R9.1, U2.10 (A3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.4 (GND), J1.29 (GND), P1.1, P2.2 (Ext), P3.2 (Ext), P4.2 (Ext), P5.2 (Ext), P6.2 (Ext), P7.2 (Ext), P8.2 (Ext), P9.2 (Ext), P10.1, P11.1, P12.1, P13.1, U1.2 (GND), U1.5 (ADDR), U2.2 (GND)
MISO: J1.15 (D12/MISO), P10.4
MOSI: J1.14 (D11/MOSI), P10.5
unnamed: P1.2, R1.1
unnamed: P2.1 (In), R2.2
unnamed: P3.1 (In), R3.2
unnamed: P4.1 (In), R4.2
unnamed: P5.1 (In), R5.2
unnamed: P6.1 (In), R6.2
unnamed: P7.1 (In), R7.2
unnamed: P8.1 (In), R8.2
unnamed: P9.1 (In), R9.2
SCK: J1.16 (SCK/D13), P10.6
SCL: J1.24 (A5), U1.3 (SCL), U2.3 (SCL)
SDA: J1.23 (A4), U1.4 (SDA), U2.4 (SDA)
VA0: J1.19 (A0), P12.5
VA1: J1.20 (A1), P12.4
VA2: J1.21 (A2), P12.3
VA3: J1.22 (A3), P12.2
VB0: J1.5 (D2/INT0), P11.5
VB1: J1.6 (D3/INT1), P11.4
VB2: J1.7 (D4/T0), P11.3
VB3: J1.8 (D5/T1), P11.2
VC0: J1.9 (D6/AIN0), P13.5
VC1: J1.10 (D7/AIN1), P13.4
VC2: J1.11 (D8/ICP), P13.3
VC3: J1.12 (D9/0C1), P13.2
~CS: J1.13 (D10/SS), P10.3

Notes on the sheet:
INPUTS WITH ANTI-ALIASING LP FILTER
ADS1115 I2C MODULES The ADC_A has 0x48 I2C address and ADC_B, 0x49
POWER INPUT The 10R resistor is used as a fuse and the 22u capacitor is used as a filter
ARDUINO NANO MODULE
ADC_A
ADC_B
MAX31856 Temperature Module Header
Digital Voltage Amplifier Controls

Board: 2 copper layers, 78.8 x 117.5 mm, 34 parts (0 on the bottom side), 37 nets.

## KiCad design Circuits/V_AMP/V_AMP.kicad_pcb

Board: 2 copper layers, 86.5 x 53.5 mm, 49 parts (0 on the bottom side), 27 nets.

Parts:
C1: 470n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C2: 220n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C3, C4, C6, C7, C8: 100n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C5: 100n; C_Rect_L9.0mm_W2.5mm_P7.50mm_MKT
C9: 10u; CP_Radial_D5.0mm_P2.50mm
C10, C11: 22u; CP_Radial_D5.0mm_P2.50mm
D1, D2, D4, D6: 5V1; D_DO-41_SOD81_P7.62mm_Horizontal
D3: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D5: SATURATION; LED_D5.0mm
P1: INPUT; bornier2
P2: OUTPUT; bornier2
P3: CONTROL_IN; kk100_22-23-2051
P4: POWER; bornier3
R1, R4, R5, R10, R11: 100k; RC03
R2, R14: 1k; RC03
R3: 22k; RC03
R6: 3k3; RC03
R7: 5k6; RC03
R8, R12, R15, R24: 2k7; RC03
R9: 27k; RC03
R13: 10k; RC03
R16, R17: 10; RC03
R18, R19: 750; RC03
R20, R21: 150; RC03
R22: 820; RC03
R23: DNP; RC03
RV1: 2k; Potentiometer_Trimmer_Bourns_3296X
U1: OPA277; DIP-8_W7.62mm_Socket_LongPads
U2: LM393; DIP-8_W7.62mm_Socket_LongPads
U3: DG412xJ; DIP-16_W7.62mm_Socket_LongPads

Connections:
+8V: C3.2, C6.2, C8.2, C11.1, R6.1, R15.1, R16.1, R22.2, U1.7, U2.8, U3.13
-8V: C4.2, C5.2, C7.1, C10.2, R17.1, U1.4, U2.4, U3.4
GND: C1.2, C3.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.2, C10.1, C11.2, D2.2, D4.2, D6.2, P1.2, P2.1, P3.1, P4.1, R1.2, R4.1, R5.1, R7.2, R10.1, R11.1, R19.1, R21.1, R23.1, U2.5, U2.6, U3.5
IN1: C1.1, R3.1, R23.2, U1.3
unnamed: C2.2, U1.2, U3.3, U3.7, U3.11, U3.14
unnamed: C9.1, D4.1, R22.1, U3.12
unnamed: D1.1, D2.1
unnamed: D1.2, R2.1, R3.2
unnamed: D3.1, D5.1, U2.1
unnamed: D3.2, R9.1
unnamed: D5.2, R15.2
unnamed: D6.1, P2.2, R24.1
unnamed: P1.1, R1.1, R2.2
unnamed: P4.2, R17.2
unnamed: P4.3, R16.2
unnamed: R6.2, R7.1, R9.2, U2.3
unnamed: R8.1, U2.2
unnamed: R12.2, U3.2
unnamed: R13.1, R14.2, U3.6
unnamed: R13.2, RV1.1, RV1.2
unnamed: R14.1, R18.2, R20.2, U3.10
unnamed: R18.1, R19.2, R20.1, R21.2, U3.15
OUT1: C2.1, R8.2, R12.1, R24.2, RV1.3, U1.6
b0: P3.5, R4.2, U3.1
b1: P3.4, R5.2, U3.8
b2: P3.3, R10.2, U3.9
b3: P3.2, R11.2, U3.16

## KiCad design Circuits/P_SUPPLY/P_SUPPLY.kicad_pcb

Parts:
C1, C4, C6: 100u; C_Rect_L7.0mm_W2.0mm_P5.00mm
C2: 1000u; CP_Radial_D10.0mm_P5.00mm
C3, C7: 22u; CP_Radial_D5.0mm_P2.50mm
C5: 10u; CP_Radial_D5.0mm_P2.50mm
D1, D7: -8V; LED_D5.0mm
D2: +5V; LED_D5.0mm
D3, D4, D5, D6: 1N4001; D_DO-35_SOD27_P7.62mm_Horizontal
F1: 100mA; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
F2, F3: 1A; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
P1: 127VAC; bornier2
P2: ON/OFF SW; bornier2
P3: SYMMETRIC 8V OUT; bornier3
P4: +5V OUTPUT; bornier2
R1, R2, R3: 1k; RC03
T1: 127:12; 12V_transformer-3T
U1: LM7808CT; TO-220
U2: LM7805CT; TO-220
U3: LM7908CT; TO-220

Connections:
+5V: C5.1, P4.1, R2.1, U2.3 (OUT)
+8V: C3.1, P3.1, R1.1, U1.3 (OUT)
+12V: C1.1, C2.1, C4.1, D5.1 (K), D6.1 (K), U1.1 (IN), U2.1 (IN)
-8V: C7.2, P3.3, R3.1, U3.2 (IN)
-12V: C6.2, D3.2 (A), D4.2 (A), U3.3 (OUT)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, D1.1 (K), D2.1 (K), D7.2 (A), P3.2, P4.2, T1.2 (PM), U1.2 (GND), U2.2 (GND), U3.1 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.1 (K), D5.2 (A), F2.2
unnamed: D4.1 (K), D6.2 (A), F3.2
unnamed: D7.1 (K), R3.2
unnamed: F1.1, P1.2
unnamed: F1.2, T1.4 (S1)
unnamed: F2.1, T1.3 (PR2)
unnamed: F3.1, T1.1 (PR1)
unnamed: P1.1, P2.2
unnamed: P2.1, T1.5 (S2)

Notes on the sheet:
BRIDGE
TRANSFORMER MODULE W/ DIODE BRIDGE AND FUSES
+5V REGULATOR W/ LED INDICATOR
+8V REGULATOR W/ LED INDICATOR
-8V REGULATOR W/ LED INDICATOR
POWER SUPPLY OUTPUTS

Board: 2 copper layers, 124.5 x 84.2 mm, 28 parts (0 on the bottom side), 17 nets.

## KiCad design Circuits/I_AMP/I_AMP.kicad_pcb

Parts:
C1, C4: 22u; CP_Radial_D5.0mm_P2.50mm
C2, C3, C6, C7: 100n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C5: 10u; CP_Radial_D5.0mm_P2.50mm
C8, C9: 220n; C_Rect_L7.0mm_W2.5mm_P5.00mm
D1, D2, D3: 1n4148; D_DO-35_SOD27_P7.62mm_Horizontal
D4: SATURATION_LED; LED_D5.0mm
D5: 5V1; D_DO-41_SOD81_P7.62mm_Horizontal
P1: INPUT; bnc-ci
P2: POWER; bornier3
P5: GAIN_ADJ.; pin_strip_2mm_2
P6: OUTPUT (0-5V); bnc-ci
R1, R2: 2R2; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal
R3, R4: 10; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R5, R6, R7: 20k; RC03
R8, R14: 10k; RC03
R9: 3k3; RC03
R10: 5k6; RC03
R11, R16, R17: 2k7; RC03
R12: 18k; RC03
R13, R18: 27k; RC03
R15: RX; RC03
R19: 100; RC03
RV1: 5k; Potentiometer_Alps_RK163_Single_Vertical
RV2: 50k; Potentiometer_Alps_RK163_Single_Vertical
U1: TL062; DIP-8_W7.62mm_Socket_LongPads
U2: LM393; DIP-8_W7.62mm_Socket_LongPads
U3: OPA277; DIP-8_W7.62mm_Socket_LongPads

Connections:
+8V: C3.2, C4.1, C7.2, R3.1, R9.1, R17.1, U1.8 (V+), U2.8 (V+), U3.7 (V+)
-8V: C1.2, C2.2, C6.2, R4.1, U1.4 (V-), U2.4 (V-), U3.4 (V-)
GND: C1.1, C2.1, C3.1, C4.2, C6.1, C7.1, C8.2, D5.2 (A), P1.2 (Ext), P2.1, P5.2, P6.2 (Ext), R1.2, R2.2, R10.2, R15.2, U1.3 (+), U1.5 (+), U2.5 (+), U2.6 (_)
I_RECTF: C5.1, R14.2, RV1.2, RV1.3, U1.7
I_RECTF_AMP: C9.1, R11.2, R18.1, R19.2, U3.6 (OUTPUT)
unnamed: C5.2, R7.1, R8.1, R12.2, U1.6 (-)
unnamed: C8.1, R14.1, R15.1, U3.3 (NON)
unnamed: C9.2, R16.1, R18.2, U3.2 (INVERTING)
unnamed: D1.1 (K), R5.1, R6.2, U1.2 (-)
unnamed: D1.2 (A), D2.1 (K), U1.1
unnamed: D2.2 (A), R6.1, R8.2
unnamed: D3.1 (K), D4.1 (K), U2.1
unnamed: D3.2 (A), R13.1
unnamed: D4.2 (A), R17.2
unnamed: D5.1 (K), P6.1 (In), R19.1
unnamed: P2.2, R4.2
unnamed: P2.3, R3.2
unnamed: P5.1, RV2.1, RV2.2
unnamed: R9.2, R10.1, R13.2, U2.3 (+)
unnamed: R11.1, U2.2 (_)
unnamed: R12.1, RV1.1
unnamed: R16.2, RV2.3
V1_I: P1.1 (In), R1.1, R2.1, R5.2, R7.2

Notes on the sheet:
POWER - Symmetric 8V
Saturation Indicator
I to V Converter
1-10x Amplifier
Full Wave Rectifier with Offset Null and Constant Time Adjust
GND

Board: 2 copper layers, 98.0 x 61.5 mm, 42 parts (0 on the bottom side), 23 nets.

## KiCad design Circuits/I_SOURCE/I_SOURCE.kicad_pcb

Parts:
C1, C4: 22u; CP_Radial_D5.0mm_P2.50mm
C2, C3, C6: 100n; C_Rect_L7.0mm_W2.5mm_P5.00mm
C5: 100u; CP_Radial_D6.3mm_P2.50mm
C7: 100n; CP_Radial_D5.0mm_P2.50mm
D1: SATURATION_LED; LED_D5.0mm
P1: POWER; bornier3
P2: I_SELECT; Pin_Header_Straight_1x03_Pitch2.00mm
P3: OUTPUT; bnc-ci
Q1: TIP127; TO-220
R1: 1k; RC03
R2: 6k8; RC03
R3, R4: 0,1; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R5, R8, R11, R13: 2k7; RC03
R6: 10; RC03
R7: 27k; RC03
R9: 18k; RC03
R10: 3R3; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
R12: 2R; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal
U1: CA3140; DIP-8_W7.62mm_LongPads
U2: LM393; DIP-8_W7.62mm_LongPads

Connections:
+8V: C2.2, C4.1, C7.2, R1.1, R3.1, R8.1, R10.1, R12.1, R13.1, U1.4 (V-), U2.8 (V+)
-8V: C1.2, C3.2, C6.2, R4.1, U1.7 (V+), U2.4 (V-)
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.1, C7.1, P1.1, P3.2, R2.2, R7.2, R9.2, U2.2 (_), U2.3 (+)
I_OUT: C5.1, P3.1, Q1.2 (C), R7.1, R11.2
unnamed: D1.1 (K), U2.7
unnamed: D1.2 (A), R13.2
unnamed: P1.2, R4.2
unnamed: P1.3, R3.2
unnamed: P2.1, R12.2
unnamed: P2.2, Q1.3 (E), R5.1
unnamed: P2.3, R10.2
unnamed: Q1.1 (B), R6.1
unnamed: R1.2, R2.1, U1.3 (NON)
unnamed: R5.2, U1.2 (INVERTING)
unnamed: R6.2, U1.6 (OUTPUT)
unnamed: R8.2, R9.1, U2.5 (+)
unnamed: R11.1, U2.6 (_)

Notes on the sheet:
POWER - Symmetric 8V
Saturation Indicator
-> 300/500mA
Current Source (300/500mA)
500mA
300mA
Common

Board: 2 copper layers, 74.8 x 50.0 mm, 27 parts (0 on the bottom side), 17 nets.

## Commit log

2017-07-12 primeiro commit
2017-07-18 Adicionado algoritmo de amostragem constante
2017-09-19 EDIT: Organização de arquivos de código
2017-09-19 Adicionado código de leitura do ADC e impressão na serial
2017-09-19 Adicionadas as dependências de Instalação
2017-09-19 EDIT: README.md sintaxe
2017-09-21 Corrigido detalhe no README.md
2017-10-03 Mudança de biblioteca gráfica para PyQtGraph na interface
2017-10-04 Corrigido Erro de escala de eixos
2017-10-04 ADD: Comentários
2017-10-07 Adição do gráfico em um QGraphicsScene para torná-lo um Widget
2017-10-12 Separação em Classes e Adição do grafico numa GUI
2017-10-13 Atualizado o README.md para o novo nome do projeto
2017-10-25 Transcrição do código para orientação a objeto
2017-10-25 Adição dos códigos para o ADS1115 com leitura dos 4 canais
2017-10-26 Configuração do ADC e da interface para 4 canais simultâneos
2017-10-27 Adição de mais 4 sensores, dois ADCs, 8 canais em simultâneo
2017-10-30 Adicionados arquivos de layout de interface
2017-11-01 Construído Esqueleto da Interface - Parte 1: Calibração P
2017-11-01 Criação do Esqueleto da Interface da Etapa 2: Calibração Temp.
2017-11-10 Funcionando o código separado em classes, nomeação de componentes gráficos e alteração dinâmica de escala de gráficos
2017-11-14 Separação de classes em arquivos e config. serial na interface
2017-11-14 Adicionado Requisito do PyQt5
2017-11-14 Adicionado requisito python 3
2017-11-16 Implementada pausa na amostragem
2017-11-16 Bug na mudança de escala
2017-11-18 Adicionadas funções aos componentes gráficos e amostragem dinamicamente correta
2017-11-18 Adição da Pasta de Arquivos de Documentação
2017-11-18 Adicionado imagem do sistema no README.md
2017-11-23 Implementados os timers e Eixos Y independentes
2017-11-24 Construida a interface da calibração de temperatura
2017-11-24 Ajustada escala de tempo de acordo com a amostragem
2017-11-24 Adicionado arquivo da classe de manipulação de arquivos
2017-11-24 Modificado o nome da main para o nome do projeto
2017-11-27 Adicionada Classe abstrata Inter faceTimer para gerenciar os timers da interdace
2017-11-29 Padronização das interfaces e gráficos genéricos com n eixos
2017-12-01 Feita a documentação da classe Graph e generalizada a mesma para n curvas
2017-12-01 Ajuste de escalas de curvas configurado e atualização da documentação
2017-12-01 Adição de avisos em caso de dados inválidos na atualização
2017-12-05 Engine adaptado para novo modelo da classe Graph
2017-12-05 ADD: Amplificadores de Corrente e Tensão
2017-12-11 Adicionada fonte de corrente e corrigido sensor de corrente
2017-12-15 ADD: Schematic Documentation
2017-12-18 Complete PCB Design of the PreAmp 10-100
2018-01-19 Added full schematics and power supply
2018-01-29 ADD: Complete Power Supply SCH+PCB
2018-01-31 EDIT: Page SETUP
2018-01-31 General amplifier 3D visualizations
2018-01-31 ADD: Power Supply Board 3D Visualizations
2018-01-31 EDIT: Reorganize Files
2018-01-31 EDIT: Reorganizing Files
2018-01-31 ADD: Current Source full PCB design
2018-01-31 ADD: Holes in Power Supply PCB
2018-01-31 EDIT: Shunt power resistors for alimentation input
2018-02-26 ADD: Current Amplifier Complete PCB Design
2018-02-26 EDIT: Correction of some jumpers
2018-02-28 ADD: Complete SCH+PCB of the ADC/MCU Board
2018-03-01 ADD: Complete Current Source SCH+PCB w/ Gerbers
2018-03-01 EDIT: Update F.Silks and BOM of the Current Source Board
2018-03-01 EDIT: Power Supply PCB Correction and ADD BOM
2018-03-01 ADD: Current Sensor Fabrication Files
2018-03-12 ADD: Current Source fabrication files
2018-03-12 ADD: ADC/MCU Module Fabrication Files
2018-03-12 EDIT: Correction of the Current Sensor board
2018-03-12 ADD: Power Supply Fabrication Files
2018-03-12 ADD: Temperature Sensor Module SCH + PCB + Fabrication Files
2018-03-12 EDIT: Some Modifications in the General Amplifier
2018-03-16 Set theme jekyll-theme-midnight
2018-04-13 EDIT: git attributes
2018-04-13 EDIT: V_AMP is a PGA now
2018-04-20 ADD: Code comments
2018-05-22 ADD: V_AMP pcb design
2018-05-22 ADD: V_AMP Fabrication Files
2018-06-19 EDIT: code comments
2018-06-19 EDIT: ADC_MCU new schematic
2018-06-19 ADD: Schematics PDF Files
2018-07-23 ADD: ADC_MCU New Schematic
2018-10-02 ADD: MainWindow and it's functionalities
2018-10-04 EDIT: Solved - Dynamic Scales and Arrays Sizing
2018-10-04 ADD: Temperature Calibration Access via Main Window
2018-10-04 ADD: Integration between InterfaceTimer and TempCalib classes
2018-10-04 ADD: LAPMA, CTA and UFRGS logos added to the main screen
2018-10-04 ADD: New Firmware code Writen in C++ using pio
2018-10-08 ADD: ThermoCouple library class
2018-10-08 ADD: Interface controls number of stream channels
